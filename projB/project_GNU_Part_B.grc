options:
  parameters:
    generate_options: qt_gui
    id: partA
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '20000'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: '250'
  states: {}
- name: fsk_deviation_hz
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '5000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e5
  states: {}
- name: samples_per_second
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /ad/eng/users/k/r/kremerme/Desktop/ec415/projB/TransmitTest_p1.iq
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /ad/eng/users/k/r/kremerme/Desktop/ec415/projB/M4_TransmitterFlowgraphCheck.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: 1/(samp_rate/(2*math.pi*fsk_deviation_hz))
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier_freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_cutoff, filter_transition)
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Modulator output
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_gfsk_mod_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', blocks_file_sink_1, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
